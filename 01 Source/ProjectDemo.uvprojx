# Keil uVision project ProjectDemo.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: BS9044AM100 BYD Semiconductor
  pack: BYD.BYDSemi_BS9044AMXX_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) IROM2(0x60000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ProjectDemo +hex
  AfterMake: ..\02 Tool\keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x60000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASW/Functional
    ./Code/ASW/Functional/: Functional.c PowerManage.c SleepManage.c
  group BSW/FLASH
    ./Code/BSW/FLASH/: Flash_IF.c
  group BSW/CAN
    ./Code/BSW/CAN/: Can_IF.c CanMaxtrixCfg.c
  group Public/LetterShell
    ./Code/Public/LetterShell/: log.c shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_port.c
  group Public/perf_counter
    ./Code/Public/perf_counter/: perf_counter.c systick_wrapper_ual.s
  group Public/cm_backtrace
    ./Code/Public/cm_backtrace/: cm_backtrace.c cmb_fault.S
  group Drivers/Stm32Fx
    ./Code/Drivers/Stm32Fx/: UART.c WDT.c System.c
  group Main
    ./Code/ASW/: AppService_IF.c
    ./Code/BSW/: BasicsService_IF.c
    ./Code/Public/: Public_IF.c
    ./Code/Drivers/: Drivers.c
    ./Code/: main.c test.c
software components: CMSIS:CORE 5.6.0, CMSIS:BS9X44AM Header 1.1.0, Device:Interrupt Manager 1.0.0, Device:Peripheral Driver:ADC 1.1.0, Device:Peripheral Driver:CAN 1.1.0, Device:Peripheral Driver:CMP 1.1.0, Device:Peripheral Driver:CRC 1.1.0, Device:Peripheral Driver:CSE 1.1.0, Device:Peripheral Driver:DMA 1.1.0, Device:Peripheral Driver:EIM 1.1.0, Device:Peripheral Driver:EPWM 1.1.0, Device:Peripheral Driver:ERM 1.1.0, Device:Peripheral Driver:EWM 1.1.0, Device:Peripheral Driver:FLASH 1.1.0, Device:Peripheral Driver:GPIO 1.1.0, Device:Peripheral Driver:IIC 1.1.0, Device:Peripheral Driver:LIN 1.1.0, Device:Peripheral Driver:MPU 1.1.0, Device:Peripheral Driver:PWM 1.1.0, Device:Peripheral Driver:RTC 1.1.0, Device:Peripheral Driver:SCI 1.1.0, Device:Peripheral Driver:SPI 1.1.0, Device:Peripheral Driver:SRC 1.1.0, Device:Peripheral Driver:TIMER 1.1.0, Device:Peripheral Driver:TRGMUX 1.1.0, Device:Peripheral Driver:UART 1.2.0, Device:Peripheral Driver:WDT 1.1.0, Device:Startup 1.1.0
